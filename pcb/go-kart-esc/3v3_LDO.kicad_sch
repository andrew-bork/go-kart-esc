File: pcb/go-kart-esc/3v3_LDO.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U801 MIC5504-3.3YM5

Commit message: Finished PCB
Parts:
- renumbered C203 to C801, C203 to C802
